options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: filepath
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: filepath
  id: parameter
  parameters:
    label: /home/minamina/recordings/filename.wav
    short_id: p
    type: str
    value: /home/minamina/recordings/filename.wav
  states: {}

connections:
- [audio_source_0, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
